Commit message: update

File: data/models/basic/surface_act.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=5.0 3.0 1; visual box size=4.1 1.8 1
